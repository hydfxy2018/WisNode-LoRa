# IAR project Lora.ewp, settings and files
configuration sx1276mb1mas (ARM, debug)
  General.OGChipSelectEditMenu: STM32L151CB-A ST STM32L151CB-A
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: STM32L151xBA; DEBUG; USE_HAL_DRIVER; USE_BAND_868; USE_MODEM_LORA
  ICCARM.CCIncludePath2: ..\..\inc; ..\..\..\..\..\Drivers\CMSIS\Device\ST\STM32L1xx\Include; ..\..\..\..\..\Drivers\STM32L1xx_HAL_Driver\Inc; ..\..\..\..\..\Drivers\CMSIS\Include; ..\..\..\..\..\Middlewares\Third_Party\Lora\Crypto; ..\..\..\..\..\Middlewares\Third_Party\Lora\Mac; ..\..\..\..\..\Middlewares\Third_Party\Lora\Phy; ..\..\..\..\..\Middlewares\Third_Party\Lora\Utilities; ..\..\..\..\..\Middlewares\Third_Party\Lora\Core; ..\..\..\..\..\Drivers\BSP\sx1276mb1mas; ..\..\..\..\..\Drivers\BSP\sx1276mb1mas\Phy
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: Lora-RAK811.bin
  ILINK.IlinkOutputFile: RAK811.out
  ILINK.IlinkIcfFile: stm32l152xba_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration sx1272mb2das (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: STM32L152RE ST STM32L152RE
  ICCARM.CCDefines: STM32L152xE; USE_STM32L1XX_NUCLEO; USE_HAL_DRIVER; USE_BAND_868
  ICCARM.CCIncludePath2: ..\..\inc; ..\..\..\..\..\..\..\Drivers\CMSIS\Device\ST\STM32L1xx\Include; ..\..\..\..\..\..\..\Drivers\BSP\STM32L1xx_Nucleo; ..\..\..\..\..\..\..\Drivers\STM32L1xx_HAL_Driver\Inc; ..\..\..\..\..\..\..\Drivers\CMSIS\Include; ..\..\..\..\..\..\..\Middlewares\Third_Party\Lora\Crypto; ..\..\..\..\..\..\..\Middlewares\Third_Party\Lora\Mac; ..\..\..\..\..\..\..\Middlewares\Third_Party\Lora\Phy; ..\..\..\..\..\..\..\Middlewares\Third_Party\Lora\Utilities; ..\..\..\..\..\..\..\Drivers\BSP\X_NUCLEO_IKS01A1; ..\..\..\..\..\..\..\Drivers\BSP\Components\Common; ..\..\..\..\..\..\..\Drivers\BSP\Components\hts221; ..\..\..\..\..\..\..\Drivers\BSP\Components\lps25hb; ..\..\..\..\..\..\..\Middlewares\Third_Party\Lora\Core; ..\..\..\..\..\..\..\Drivers\BSP\sx1276mb1mas; ..\..\..\..\..\..\..\Drivers\BSP\sx1276mb1mas\Phy; ..\..\..\..\..\..\..\Drivers\BSP\sx1272mb2das; ..\..\..\..\..\..\..\Drivers\BSP\sx1272mb2das\Phy; ..\..\..\..\..\..\..\Drivers\BSP\sx1276mb1las; ..\..\..\..\..\..\..\Drivers\BSP\sx1276mb1las\Phy; ..\..\..\..\..\..\..\Drivers\BSP\Components\lps22hb
  ICCARM.CCOptLevel: 3
  OBJCOPY.OOCOutputFile: Lora-sx1272mb2das.hex
  ILINK.IlinkOutputFile: sx1272mb2das.out
  ILINK.IlinkIcfFile: stm32l152xe_flash.icf
configuration sx1276mb1las (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: STM32L152RE ST STM32L152RE
  ICCARM.CCDefines: as above
  ICCARM.CCIncludePath2: as above
  ICCARM.CCOptLevel: 3
  OBJCOPY.OOCOutputFile: Lora-sx1276mb1las.hex
  ILINK.IlinkOutputFile: sx1276mb1las.out
  ILINK.IlinkIcfFile: stm32l152xe_flash.icf
  group Drivers/BSP/sx1276mb1mas
    ../../../../../Drivers/BSP/sx1276mb1mas/Phy/: sx1276.c
    ../../../../../Drivers/BSP/sx1276mb1mas/: sx1276mb1mas.c
  group Drivers/CMSIS
    ../../../../../Drivers/CMSIS/Device/ST/STM32L1xx/Source/Templates/: system_stm32l1xx.c
  group Drivers/STM32L1xx_HAL_Driver
    ../../../../../Drivers/STM32L1xx_HAL_Driver/Src/: stm32l1xx_hal.c stm32l1xx_hal_adc.c stm32l1xx_hal_adc_ex.c stm32l1xx_hal_cortex.c stm32l1xx_hal_dma.c stm32l1xx_hal_gpio.c stm32l1xx_hal_i2c.c stm32l1xx_hal_pwr.c stm32l1xx_hal_pwr_ex.c stm32l1xx_hal_rcc.c stm32l1xx_hal_rcc_ex.c stm32l1xx_hal_rtc.c stm32l1xx_hal_rtc_ex.c stm32l1xx_hal_spi.c stm32l1xx_hal_spi_ex.c stm32l1xx_hal_tim.c stm32l1xx_hal_tim_ex.c stm32l1xx_hal_uart.c
  group Middlewares/Lora/Core
    ../../../../../Middlewares/Third_Party/Lora/Core/: lora.c
  group Middlewares/Lora/Crypto
    ../../../../../Middlewares/Third_Party/Lora/Crypto/: aes.c cmac.c
  group Middlewares/Lora/Mac
    ../../../../../Middlewares/Third_Party/Lora/Mac/: LoRaMac.c LoRaMacCrypto.c
  group Middlewares/Lora/Utilities
    ../../../../../Middlewares/Third_Party/Lora/Utilities/: delay.c low_power.c timeServer.c utilities.c
  group Projects/classA
    ../../src/: main.c
  group Projects/common
    ../../src/: bsp.c debug.c hw_gpio.c hw_rtc.c hw_spi.c stm32l1xx_hal_msp.c stm32l1xx_hw.c stm32l1xx_it.c vcom.c
  group Projects/EWARM
    ./: startup_stm32l151xb.s startup_stm32l151xba.s
  group Projects/PingPong
    ../../../PingPong/: main.c
